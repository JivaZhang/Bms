# IAR project bms.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031C4 ST STM32L031C4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L031xx
  ICCARM.CCIncludePath2: ../project/Inc; ../project/API/inc; ../project/Application/inc; ../project/HalApi/inc; ../project/Os/inc; ../project/Drivers/STM32L0xx_HAL_Driver/Inc; ../project/Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../project/Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../project/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bms.bin
  ILINK.IlinkOutputFile: bms.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L051C8 ST STM32L051C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; USE_HAL_DRIVER; STM32L031xx
  ICCARM.CCOptLevel: 0
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32l051x8.icf
  group API
    ../project/API/src/: afe.c battercom.c chargedischarge.c debug.c eeprom.c gauge.c key.c led.c
    ../project/API/inc/: afe.h battercom.h chargedischarge.h debug.h eeprom.h gauge.h key.h led.h
  group Application
    ../project/Application/src/: bmsnormal.c bmsship.c bmsstart.c main.c
    ../project/Application/inc/: bmsnormal.h bmsship.h bmsstart.h
  group Drivers/CMSIS
    ../project/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/EWARM
    ../project/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: startup_stm32l031xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../project/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group HalApi
    ../project/HalApi/src/: adc.c gpio.c i2c.c timer.c usart.c
    ../project/HalApi/inc/: adc.h clock.h gpio.h i2c.h timer.h usart.h
    ../project/Application/src/: clock.c
    ../project/API/src/: systemDefault.c
    ../project/API/inc/: systemDefault.h
